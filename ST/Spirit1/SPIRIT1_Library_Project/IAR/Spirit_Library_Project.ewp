# IAR project Spirit_Library_Project.ewp, settings and files
configuration SDK_BasicGeneric_A (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; STM32L1XX_MD; IAR_ARM_CM3; USE_FULL_ASSERT; SPIRIT_USE_FULL_ASSERT; USE_SYSTICK_DELAY
  ICCARM.CCIncludePath2: .; ..\Test; ..\Test\examples; ..\Test\runtime; ..\Source\SDK_Eval\inc; ..\Source\SPIRIT1_Libraries\inc; ..\Source\SPIRIT1_Application\inc; ..\..\STM32L1xx_StdPeriph_Lib\Source\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\STM32L1xx_StdPeriph_Lib\Source\STM32L1xx_StdPeriph_Driver\inc; ..\..\SpiritSDK_Virtual_Com\Source\inc; ..\..\STM32_USB-FS-Device_Lib\Source\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: SDK_BasicGeneric_A.hex
  ILINK.IlinkOutputFile: Spirit_Libraries.out
  ILINK.IlinkIcfFile: stm32l1xx_flash_offset.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SDK_BasicGeneric_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; STM32L1XX_MD; IAR_ARM_CM3; USE_FULL_ASSERTx; SPIRIT_USE_FULL_ASSERTx; USE_SYSTICK_DELAY
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_BasicGeneric_B.hex
configuration SDK_BasicPktMonitoring_A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; STM32L1XX_MD; IAR_ARM_CM3; USE_FULL_ASSERT; SPIRIT_USE_FULL_ASSERT; USE_SYSTICK_DELAY; DEVICE_A
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_BasicPktMonitoring_A.hex
configuration SDK_BasicPktMonitoring_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; VECT_TAB_FLASH; STM32L1XX_MD; IAR_ARM_CM3; USE_FULL_ASSERT; SPIRIT_USE_FULL_ASSERT; USE_SYSTICK_DELAY; DEVICE_B
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_BasicPktMonitoring_B.hex
configuration SDK_BasicPktTest_A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_BasicPktTest_A.hex
configuration SDK_BasicPktTest_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_BasicPktTest_B.hex
configuration SDK_Csma_A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_Csma_A.hex
configuration SDK_Csma_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_Csma_B.hex
configuration SDK_Csma_TxCW (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_Csma_TxCW.hex
configuration SDK_Encryption_A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_Encryption_A.hex
configuration SDK_Encryption_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_Encryption_B.hex
configuration SDK_FifoHandler_A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_FifoHandler_A.hex
configuration SDK_FifoHandler_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_FifoHandler_B.hex
configuration SDK_Ldcr_A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_Ldcr_A.hex
configuration SDK_Ldcr_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_Ldcr_B.hex
configuration SDK_MbusGeneric_A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_MbusGeneric_A.hex
configuration SDK_MbusGeneric_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_MbusGeneric_B.hex
configuration SDK_PingPong_A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_PingPong_A.hex
configuration SDK_PingPong_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_PingPong_B.hex
configuration SDK_Radio_A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_Radio_A.hex
configuration SDK_Radio_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_Radio_B.hex
configuration SDK_StackGeneric_A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_StackGeneric_A.hex
configuration SDK_StackGeneric_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_StackGeneric_B.hex
configuration SDK_StackLlp_A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_StackLlp_A.hex
configuration SDK_StackLlp_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_StackLlp_B.hex
configuration SDK_WirelessTerminal_A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_WirelessTerminal_A.hex
configuration SDK_WirelessTerminal_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_WirelessTerminal_B.hex
configuration SDK_WMbusStd_A (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_WMbusStd_A.hex
configuration SDK_WMbusStd_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SDK_WMbusStd_B.hex
  group Runtime
    ../Test/runtime/iar/: startup_stm32l1xx_md.s
    ../Test/runtime/: system_stm32l1xx.c
  group SDK_Eval/inc
    ../Source/SDK_Eval/inc/: SDK_EVAL_Button.h SDK_EVAL_Com.h SDK_EVAL_Config.h SDK_EVAL_Led.h SDK_EVAL_PM.h SDK_EVAL_Spirit_Gpio.h SDK_EVAL_Spirit_Spi_Config.h SDK_EVAL_Timers.h
  group SDK_Eval/src
    ../Source/SDK_Eval/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Led.c SDK_EVAL_PM.c SDK_EVAL_Spirit_Gpio.c SDK_EVAL_Spirit_Spi_Driver.c SDK_EVAL_Timers.c
  group SDK_Eval_VC/inc
    ../../SpiritSDK_Virtual_Com/Source/inc/: SDK_EVAL_VC_Desc.h SDK_EVAL_VC_General.h SDK_EVAL_VC_Istr.h SDK_EVAL_VC_Prop.h SDK_EVAL_VC_Pwr.h usb_conf.h
  group SDK_Eval_VC/src
    ../../SpiritSDK_Virtual_Com/Source/src/: SDK_EVAL_VC_Desc.c SDK_EVAL_VC_Endp.c SDK_EVAL_VC_General.c SDK_EVAL_VC_Istr.c SDK_EVAL_VC_Prop.c SDK_EVAL_VC_Pwr.c
  group SPIRIT1_Libraries/inc
    ../Source/SPIRIT1_Libraries/inc/: SPIRIT_Aes.h SPIRIT_Calibration.h SPIRIT_Commands.h SPIRIT_Config.h SPIRIT_Csma.h SPIRIT_DirectRF.h SPIRIT_General.h SPIRIT_Gpio.h SPIRIT_Irq.h SPIRIT_LinearFifo.h SPIRIT_PktBasic.h SPIRIT_PktCommon.h SPIRIT_PktMbus.h SPIRIT_PktStack.h SPIRIT_Qi.h SPIRIT_Radio.h SPIRIT_Regs.h SPIRIT_Spi_Driver.h SPIRIT_Timer.h SPIRIT_Types.h
  group SPIRIT1_Libraries/src
    ../Source/SPIRIT1_Libraries/src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
  group SPIRIT1_Management/inc
    ../Source/SPIRIT1_Application/inc/: SPIRIT_Management.h
  group SPIRIT1_Management/src
    ../Source/SPIRIT1_Application/src/: SPIRIT_Management.c
  group STM32_USB-FS-Device_Driver/inc
    ../../STM32_USB-FS-Device_Lib/Source/inc/: usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
  group STM32_USB-FS-Device_Driver/src
    ../../STM32_USB-FS-Device_Lib/Source/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32L1xx_StdPeriph_Lib/inc
    ../../STM32L1xx_StdPeriph_Lib/Source/STM32L1xx_StdPeriph_Driver/inc/: misc.h stm32l1xx_adc.h stm32l1xx_comp.h stm32l1xx_crc.h stm32l1xx_dac.h stm32l1xx_dbgmcu.h stm32l1xx_dma.h stm32l1xx_exti.h stm32l1xx_flash.h stm32l1xx_gpio.h stm32l1xx_i2c.h stm32l1xx_iwdg.h stm32l1xx_lcd.h stm32l1xx_pwr.h stm32l1xx_rcc.h stm32l1xx_rtc.h stm32l1xx_spi.h stm32l1xx_syscfg.h stm32l1xx_tim.h stm32l1xx_usart.h stm32l1xx_wwdg.h
  group STM32L1xx_StdPeriph_Lib/src
    ../../STM32L1xx_StdPeriph_Lib/Source/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group Test
    ../Test/examples/BasicGeneric/: SDK_BasicGeneric_A.c SDK_BasicGeneric_B.c
    ../Test/examples/BasicPktMonitoring/: SDK_BasicPktCommon.c SDK_BasicPktCommon.h SDK_BasicPktMonitoring_A.c SDK_BasicPktMonitoring_B.c
    ../Test/examples/BasicPktTest/: SDK_BasicPktTest_A.c SDK_BasicPktTest_B.c SDK_BasicPktTest_Common.h
    ../Test/examples/CsmaGeneric/: SDK_Csma_A.c SDK_Csma_B.c SDK_Csma_TxCW.c
    ../Test/examples/EncryptionGeneric/: SDK_Encryption_A.c SDK_Encryption_B.c
    ../Test/examples/FifoHandler/: SDK_FifoHandler_A.c SDK_FifoHandler_B.c
    ../Test/examples/LdcrGeneric/: SDK_LDCR_A.c SDK_LDCR_B.c
    ../Test/examples/WMbusGeneric/: SDK_MbusGeneric_A.c SDK_MbusGeneric_B.c
    ../Test/examples/PingPong/: SDK_PingPong_A.c SDK_PingPong_B.c
    ../Test/examples/RadioGeneric/: SDK_Radio_A.c SDK_Radio_B.c SDK_RadioCommon.c SDK_RadioCommon.h
    ../Test/examples/StackGeneric/: SDK_StackGeneric_A.c SDK_StackGeneric_B.c
    ../Test/examples/StackLlp/: SDK_StackLlp_A.c SDK_StackLlp_B.c
    ../Test/examples/WirelessTerminal/: SDK_WirelessTerminal_A.c SDK_WirelessTerminal_B.c
    ../Test/examples/WMbusStd/: SDK_WMbusStd_A.c SDK_WMbusStd_B.c
    ../Test/: stm32l1xx_conf.h stm32l1xx_it.c stm32l1xx_it.h
  group Test/ReadMe
    ../Test/examples/BasicGeneric/: SDK_BasicGeneric_readme.txt
    ../Test/examples/BasicPktMonitoring/: SDK_BasicPktMonitoring_readme.txt
    ../Test/examples/BasicPktTest/: SDK_BasicPktTest_readme.txt
    ../Test/examples/CsmaGeneric/: SDK_Csma_readme.txt
    ../Test/examples/EncryptionGeneric/: SDK_Encryption_readme.txt
    ../Test/examples/FifoHandler/: SDK_FifoHandler_readme.txt
    ../Test/examples/LdcrGeneric/: SDK_LDCR_readme.txt
    ../Test/examples/WMbusGeneric/: SDK_MbusGeneric_readme.txt
    ../Test/examples/PingPong/: SDK_PingPong_readme.txt
    ../Test/examples/RadioGeneric/: SDK_Radio_readme.txt
    ../Test/examples/StackGeneric/: SDK_StackGeneric_readme.txt
    ../Test/examples/StackLlp/: SDK_StackLlp_readme.txt
    ../Test/examples/WirelessTerminal/: SDK_WirelessTerminal_readme.txt
    ../Test/examples/WMbusStd/: SDK_WMbusStd_readme.txt
